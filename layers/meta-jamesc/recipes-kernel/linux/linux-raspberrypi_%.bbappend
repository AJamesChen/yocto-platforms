FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-spidev-add-MFRC522-compatible.patch"
